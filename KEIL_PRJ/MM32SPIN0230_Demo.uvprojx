# Keil uVision project MM32SPIN0230_Demo.uvprojx, settings and files
target MM32SPIN0230 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32SPIN0230B1NV MindMotion
  pack: MindMotion.MM32SPIN0230_DFP.1.1.2
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x7800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SPIN0230_DEMO +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_5V
  c include: ..\MM32SPIN0230\Include;..\MM32SPIN0230\HAL_Lib\inc;..\DRIVE\inc;..\SYSTEM\inc;..\USER\inc;..\M1_CONTROL\inc;..\MM_MCLIB\inc;..\MM_MCLIB\inc;..\MY_MC;..\MOTOR_CONTROL;..\MC_CORE;..\TM1650
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7800
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ../USER/: main.c board.c mm32_it.c user_control.c led.c flash_data_save.c tool_mode.c Bat_com.c
    ../USER/inc/: parameter.h
    ../TM1650/: tm1650.c
  group SYSTEM
    ../SYSTEM/: systick.c
  group DRIVE
    ../DRIVE/: drv_adc.c drv_comp.c drv_div.c drv_iwdg.c drv_led.c drv_opamp.c drv_pwm.c
  group HAL_LIB
    ../MM32SPIN0230/HAL_Lib/src/: hal_adc.c hal_comp.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_hwdiv.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_syscfg.c hal_tim.c hal_uid.c hal_usart.c
  group Startup
    ../MM32SPIN0230/Source/: system_mm32spin0230.c
    ../MM32SPIN0230/Source/KEIL_StartAsm/: startup_mm32spin0230_keil.s
  group MOTOR_CONTROL
    ../MOTOR_CONTROL/: motor_control.c motor_config.h
  group MC_CORE
    ../MC_CORE/: 002_mc_core_V1_01.lib
software components: CMSIS:CORE 5.6.0
